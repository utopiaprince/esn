# IAR project gateway.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  General.OGChipSelectMenu: MSP430F5419A MSP430F5419A
  General.GStackSize2: 800
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: NODE_TYPE_GATEWAY
  ICC430.newCCIncludePaths: ..\..\; ..\..\common\lib\; ..\..\sys_arch\; ..\..\sys_arch\inc\; ..\..\apps\gateway\; ..\..\apps\; ..\..\platform\core430\port\; ..\..\platform\core430\init\; ..\..\platform\core430\drivers\; ..\..\platform\core430\drivers\inc; ..\..\stack\; ..\..\stack\common\; ..\..\stack\custom\mac\; ..\..\stack\custom\phy\; ..\..\stack\module\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.ADefines: USE_LARGE_CODE_MODEL
  A430.AUserIncludes: ..\..\apps\gateway\
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430F5419A.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group apps
    ../../apps/gateway/: esn_active.c esn_detect.c esn_gain.c esn_package.c esn_restruct.c main.c
  group apps/inc
    ../../apps/gateway/: esn.h esn_active.h esn_detect.h esn_gain.h esn_package.h FreeRTOSConfig.h
  group common/lib
    ../../common/lib/: crc16.c crc16.h data_type_def.h debug.c debug.h hal_timer.c hal_timer.h lib.h mlist.c mlist.h printf.c printf.h random.c random.h
  group platform/core430/drivers
    ../../platform/core430/drivers/: adxl312.c atmosphere.c board.c cam.c clock.c gprs.c lora.c range.c uart.c
  group platform/core430/drivers/inc
    ../../platform/core430/drivers/inc/: adxl312.h atmosphere.h board.h cam.h clock.h drivers.h gprs.h lora.h range.h sht.h uart.h wts.h
  group platform/core430/init
    ../../platform/core430/init/: bsp.c bsp.h cstartup.s43
  group platform/core430/port
    ../../platform/core430/port/: data_model.h heap_1.c port.c portext.s43 portmacro.h
  group stack
    ../../stack/: stack.c stack.h
  group stack/common
    ../../stack/common/: pbuf.c pbuf.h prim.h sbuf.c sbuf.h
  group stack/custom/mac
    ../../stack/custom/mac/: mac.c mac.h mac_ctrl.c mac_ctrl.h mac_frames.c mac_frames.h mac_prim.c mac_prim.h mac_recv.c mac_recv.h
  group stack/custom/phy
    ../../stack/custom/phy/: phy_cca.c phy_cca.h phy_packet.c phy_packet.h phy_state.c phy_state.h
  group stack/module
    ../../stack/module/: m_tran.c m_tran.h module.h
  group sys_arch
    ../../sys_arch/: osel_arch.h
  group sys_arch/inc
    ../../sys_arch/inc/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group sys_arch/src
    ../../sys_arch/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
